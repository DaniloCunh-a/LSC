inherit update-rc.d

INITSCRIPT_NAME = "networking"
INITSCRIPT_PARAMS = "stop 01 0 1 2 3 4 5 6 ."

